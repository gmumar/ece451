* FILE: Carry_test.sp

.INCLUDE 'Carry_test.h'

* SPICE netlist for "Carry_test" generated by MMI_SUE5.5.4 on Wed Feb 04
*+ 15:52:12 EST 2015.

.SUBCKT inverter in out WP=2 LP=lp_min WN=1 LN=ln_min
M_1 out in gnd gnd n W='WN*1u' L=LN ad='arean(WN,sdd)'
+ as='arean(WN,sdd)' pd='perin(WN,sdd)' ps='perin(WN,sdd)'
M_2 out in vdd vdd p W='WP*1u' L=LP ad='areap(WP,sdd)'
+ as='areap(WP,sdd)' pd='perip(WP,sdd)' ps='perip(WP,sdd)'
.ENDS	$ inverter

.SUBCKT Carry Ci_1 P Phi notCi notCi_1 notG notP
Xinverter notCi_1 Ci_1 inverter
Xinverter_1 notP P inverter
Xinverter_2 notG net_1 inverter
M_1 notCi_1 P notCi gnd n W='1*1u' L=ln_min ad='arean(1,sdd)'
+ as='arean(1,sdd)' pd='perin(1,sdd)' ps='perin(1,sdd)'
M_2 notCi net_1 gnd gnd n W='1*1u' L=ln_min ad='arean(1,sdd)'
+ as='arean(1,sdd)' pd='perin(1,sdd)' ps='perin(1,sdd)'
M_3 notCi Phi vdd vdd p W='1*1u' L=lp_min ad='areap(1,sdd)'
+ as='areap(1,sdd)' pd='perip(1,sdd)' ps='perip(1,sdd)'
M_4 notP Phi vdd vdd p W='1*1u' L=lp_min ad='areap(1,sdd)'
+ as='areap(1,sdd)' pd='perip(1,sdd)' ps='perip(1,sdd)'
M_5 notG Phi vdd vdd p W='1*1u' L=lp_min ad='areap(1,sdd)'
+ as='areap(1,sdd)' pd='perip(1,sdd)' ps='perip(1,sdd)'
.ENDS	$ Carry

* start main CELL Carry_test
* .SUBCKT Carry_test Ci_1 P notCi
XCarry Ci_1 P net_4 notCi net_3 net_1 net_2 Carry
VnotG net_1 gnd PWL(0 vddp 199.9n vddp 200.1n 0 399.9n 0 400.1n vddp
+ 799.9n vddp 800.1n 0 999.9n 0 1.0001u vddp)
VnotP net_2 gnd PWL(0 0 199.9n 0 200.1n vddp 599.9n vddp 600.1n 0 799.9n
+ 0 800.1n vddp)
VnotCi_1 net_3 gnd PWL(0 0 599.9n 0 600.1n vddp)
Vclk net_4 gnd PWL(0 vddp 99.9n vddp 100.1n 0 199.9n 0 200.1n vddp
+ 299.9n vddp 300.1n 0 399.9n 0 400.1n vddp 499.9n vddp 500.1n 0 599.9n
+ 0 600.1n vddp 699.9n vddp 700.1n 0 799.9n 0 800.1n vddp 899.9n vddp
+ 900.1n 0 999.9n 0 1.0001u vddp 1.0999u vddp 1.1001u 0 1.1999u 0
+ 1.2001u vddp 1.2999u vddp 1.3001u 0 1.3999u 0 1.4001u vddp)
* .ENDS	$ Carry_test

.GLOBAL gnd vdd

.END
